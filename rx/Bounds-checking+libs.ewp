# IAR project Bounds-checking+libs.ewp, settings and files
configuration DoNotCheckPointersFromNonInstrumentedCode (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CheckPointersFromNonInstrumentedCode (RX, debug)
  as the first configuration, except:
  ICCRX.CCDefines: CHECK_POINTERS
  group (top)
    ../common/: Bounds+Lib.c
    ./: MaxLib.a
    $EW_DIR$/rx/src/lib/crun/: ReportCheckFailedStdout.c
