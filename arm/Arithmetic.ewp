# IAR project Arithmetic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Arithmetic.out
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../common/: Arithmetic.c
    $EW_DIR$/arm/src/lib/crun/: ReportCheckFailedStdout.c
