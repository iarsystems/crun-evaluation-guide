# IAR project Bounds-checking.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Boundschecking.out
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../common/: Bounds.c IntMax.c
    $EW_DIR$/arm/src/lib/crun/: ReportCheckFailedStdout.c
