# IAR project Heap.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Heap.icf
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../common/: Heap.c
    $EW_DIR$/arm/src/lib/crun/: ReportCheckFailedStdout.c
