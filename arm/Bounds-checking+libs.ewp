# IAR project Bounds-checking+libs.ewp, settings and files
configuration DoNotCheckPointersFromNonInstrumentedCode (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG=$CONFIG_NAME$
  ICCARM.CCIncludePath2: ../common
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Boundschecking_2.out
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CheckPointersFromNonInstrumentedCode (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  group (top)
    ../common/: Bounds+Lib.c
    ./: MaxLib.a
